options:
  parameters:
    generate_options: no_gui
    id: radio_process_dual_channel
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: radio_process_dual_channel
  states: {}

blocks:
- name: beam_switch
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cal_on
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cal_pwr
  id: variable
  parameters:
    value: np.array([1]*num_channels**2)
  states: {}
- name: cal_values
  id: variable
  parameters:
    value: cal_values_real+1j*cal_values_imag
  states: {}
- name: cal_values_imag
  id: variable
  parameters:
    value: np.zeros((num_channels**2,num_bins))
  states: {}
- name: cal_values_real
  id: variable
  parameters:
    value: np.ones((num_channels**2,num_bins))
  states: {}
- name: calibrator_mask
  id: variable
  parameters:
    value: '0b000000000011'
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc_samples*np.hamming(4*num_bins)
  states: {}
- name: fft_window
  id: variable
  parameters:
    value: window.blackmanharris(num_bins)
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1420000000'
  states: {}
- name: glat
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: glon
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: is_running
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: metadata_dict
  id: variable
  parameters:
    value: 'pmt.to_pmt({"num_bins": num_bins, "samp_rate": samp_rate, "num_integrations": num_integrations, "motor_az": motor_az, "motor_el": motor_el, "freq": freq, "tsys": [float(n) for n in tsys], "tcal": [float(n) for n in tcal], "cal_pwr": [float(n) for n in cal_pwr], "vlsr": vlsr, "glat": glat, "glon": glon, "soutrack": soutrack, "bsw": beam_switch})'
  states: {}
- name: motor_az
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: motor_el
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '2'
  states: {}
- name: radio_start_time
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/num_bins)
  states: {}
- name: sinc_samples
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: soutrack
  id: variable
  parameters:
    value: '"at_stow"'
  states: {}
- name: tag_period
  id: variable
  parameters:
    value: num_bins*num_integrations
  states: {}
- name: tcal
  id: variable
  parameters:
    value: np.array([290]*num_channels)
  states: {}
- name: tsys
  id: variable
  parameters:
    value: np.array([171]*num_channels)
  states: {}
- name: vlsr
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: Covariance_Matrix_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class covariance_matrix_block(gr.sync_block):
          """
          A GNU Radio block that computes the covariance matrix elements
          for FFT streams across multiple channels.
          Each output corresponds to one element in the covariance matrix.
          """

          def __init__(self, num_channels=2, vec_length=256):
              """
              Initialize the block.
              Args:
                  num_channels (int): Number of input channels.
                  vec_length (int): Number of frequency bins per FFT.
              """
              gr.sync_block.__init__(
                  self,
                  name="Covariance Calculator Block",
                  in_sig=[(np.complex64, vec_length)] * num_channels,
                  out_sig=[(np.complex64, vec_length)] * (num_channels**2),
              )
              self.num_channels = num_channels
              self.vec_length = vec_length

          def work(self, input_items, output_items):
              """
              Perform the covariance matrix computation using full vectorization.
              """

              # Rearrange spectra into a form we can easily handle
              unwrapped_input = np.array(input_items).reshape(self.num_channels,-1)

              #combined_data = np.stack(input_items[:self.num_channels], axis=0)
              spectrum_matrices = np.transpose(unwrapped_input).reshape((-1, 1, self.num_channels))

              # Get covariance matrices (shape: vec_length, num_channels, num_channels)
              covariances = np.matmul(spectrum_matrices.swapaxes(1, 2), spectrum_matrices.conjugate())

              # The shape of covariances is now (vec_length, num_channels, num_channels)
              # We need to flatten it to the shape (num_channels * num_channels, vec_length)
              covariances_reshaped = (covariances.swapaxes(0, 2).reshape(self.num_channels**2, -1, self.vec_length))

              # Assign reshaped covariance matrix elements to the output items
              for idx in range(self.num_channels**2):
                  output_items[idx][:] = covariances_reshaped[idx,:]

              # Return the number of items produced (number of bins)
              return len(output_items[0])
    num_channels: num_channels
    vec_length: num_bins
  states: {}
- name: add_clock_tags
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt


      def make_time_pair(t):
          return pmt.make_tuple(
              pmt.to_pmt(int(np.trunc(t))), pmt.to_pmt(t - int(np.trunc(t)))
          )


      class clk(gr.sync_block):
          def __init__(self, nsamps=8192):
              gr.sync_block.__init__(
                  self, name="Add Clock Tags", in_sig=[np.complex64], out_sig=[np.complex64]
              )
              self.pmt_key = pmt.intern("rx_time")
              self.offset = 0
              self.nsamps = nsamps

          def work(self, input_items, output_items):
              nitems = len(input_items[0]) + self.nitems_written(0)
              if self.nitems_written(0) == 0:
                  self.add_item_tag(0, 0, self.pmt_key, make_time_pair(time.time()))
              while (nitems - self.offset) > self.nsamps:
                  self.offset += self.nsamps
                  self.add_item_tag(0, self.offset, self.pmt_key, make_time_pair(time.time()))
              output_items[0][:] = input_items[0]  # copy input to output
              return len(output_items[0])
    nsamps: tag_period
  states: {state: disabled}
- name: add_clock_tags_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt

      def make_time_pair(t):
          return pmt.make_tuple(pmt.to_pmt(int(np.trunc(t))), pmt.to_pmt(t - int(np.trunc(t))))

      class clk(gr.sync_block):
          def __init__(self, nsamps=8192):
              gr.sync_block.__init__(
                  self,
                  name='Add Clock Tags',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.pmt_key = pmt.intern("rx_time")
              self.offset = 0
              self.nsamps = nsamps
       
          def work(self, input_items, output_items):
              nitems = len(input_items[0]) + self.nitems_written(0)
              if self.nitems_written(0) == 0:
                  self.add_item_tag(0, 0, self.pmt_key, make_time_pair(time.time()))
              while ((nitems - self.offset) > self.nsamps):
                  self.offset += self.nsamps
                  self.add_item_tag(0, self.offset, self.pmt_key, make_time_pair(time.time()))
              output_items[0][:] = input_items[0] # copy input to output
              return len(output_items[0])
    nsamps: tag_period
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: num_integrations
    type: complex
    vlen: num_bins*(num_channels**2)
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.to_pmt(is_running)
    period: int(tag_period/samp_rate*1000)
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: radio_start_time
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: cal_values[0]
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 'cal_values[3] '
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 'cal_values[1] '
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 'cal_values[2] '
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_xx_0_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0/float(num_integrations)
    type: complex
    vlen: num_bins*(num_channels**2)
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_streams_to_vector_0_0_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_streams_to_vector_1
  id: blocks_streams_to_vector
  parameters:
    num_streams: num_channels**2
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("rx_freq")
    nsamps: tag_period
    type: complex
    value: pmt.to_pmt(float(freq))
  states: {state: disabled}
- name: blocks_tags_strobe_0_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("metadata")
    nsamps: tag_period
    type: complex
    value: metadata_dict
  states: {state: disabled}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: num_channels**2
    type: complex
    vlen: num_bins
  states: {}
- name: calibrator_control_strobe
  id: epy_block
  parameters:
    _source_code: |
      """
      block to generate calibrator control commands for the X300 radio. 
      note that this block assumes a latency lower than the calibrator cycle time
      and will break if that condition is not met

      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import numpy as np
      from gnuradio import gr 
      import pmt
      import time
      import uhd

      class msg_blk(gr.sync_block):
          def __init__(self, calibrator_mask=0xFFF,cal_state=0):
              gr.sync_block.__init__(
                  self,
                  name="calibrator_msg_block",
                  in_sig=None,
                 out_sig=None
              )

              #input parameters
              self.calibrator_mask = calibrator_mask
              self.cal_state = cal_state

              #derived variables

              self.last_cal_state = 0
              #self.cal_value = 0x000
              
              self.message_port_register_in(pmt.intern('strobe'))
              self.message_port_register_out(pmt.intern('command'))
              
              self.set_msg_handler(pmt.intern('strobe'), self.handle_msg)

          def handle_msg(self, msg):

              #send message to define next calibrator state change

              if self.last_cal_state != self.cal_state:
                  cal_value = self.cal_state
                      
                  #issue command to toggle gpio
                  set_gpio = pmt.make_dict()
                  set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('bank'), pmt.to_pmt('FP0A'))
                  set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('attr'), pmt.to_pmt('OUT'))
                  set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('value'), pmt.from_double(cal_value))
                  set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('mask'), pmt.from_double(self.calibrator_mask))
                  
                  msg = pmt.make_dict()
                  msg = pmt.dict_add(msg, pmt.to_pmt('gpio'), set_gpio)
                  self.message_port_pub(pmt.intern('command'), msg) #issue message
                  
                  self.last_cal_state = self.cal_state
                  
              #otherwise do nothing        
    cal_state: cal_on
    calibrator_mask: calibrator_mask
  states: {state: disabled}
- name: calibrator_control_strobe_0
  id: epy_block
  parameters:
    _source_code: |-
      """

      This block generates synchronous calibrator control commands timed to the edge of
      integration periodsb to control the X300 radio GPIO. 
      It also manages all metadata tagging to enable an applied lag for the calibrator state information

      note that this block assumes a latency lower than the calibrator cycle time
      and will break if that condition is not met. modified to add timestamps on 2024/12/23

      """
      import numpy as np
      from gnuradio import gr 
      import pmt
      import time
      import uhd

      def make_time_pair(t):
          return pmt.make_tuple(
              pmt.to_pmt(int(np.trunc(t))), pmt.to_pmt(t - int(np.trunc(t)))
          )

      class tagging_and_ctl(gr.sync_block):
          def __init__(self, num_channels=2, cal_mask=0xFFF, cal_state=0, integration_time=1.0, samp_rate=32e3, center_frequency=1.42e9, metadata_pmt=pmt.to_pmt({"num_bins":512})):
              gr.sync_block.__init__(
                  self,
                  name="metadata_tagging_and_control",
                  in_sig=[np.complex64]*num_channels,
                  out_sig=[np.complex64]*num_channels
              )

              #input parameters
              self.cal_mask = cal_mask
              self.integration_time = integration_time
              self.cal_state = cal_state
              self.samp_rate = samp_rate
              self.num_channels = num_channels
              self.metadata_pmt = metadata_pmt
              self.center_frequency=center_frequency

              #fixed derived variables

              self.calibrator_sample_interval = int(self.samp_rate * self.integration_time)

              self.last_cal_state = False
              self.rx_time = None
              self.next_cal_time = None

              self.offset = 0
              
              #self.message_port_register_in(pmt.intern('get_gpio'))
              self.message_port_register_out(pmt.intern('command'))
              self.message_port_register_out(pmt.intern('time_reference'))
              #self.set_msg_handler(pmt.intern('gpio_command'), self.handle_msg)

          def work(self, input_items, output_items):


              #when SDR first starts, capture its internal timestamp off the first sample. use to time all subsequent events
              #ONLY accept radio timestamp once. It gets resent upon tuning commands and thoroughly borks things

              if self.rx_time == None:

                  tags = self.get_tags_in_window(0, 0, len(input_items[0]))

                  for tag in tags:
                      key = pmt.to_python(tag.key) # convert from PMT to python string
                      if key == "rx_time":
                          self.rx_time = pmt.to_python(tag.value) 

                          rx_time_float = self.rx_time[0]+self.rx_time[1]
                          msg = pmt.cons(pmt.string_to_symbol('radio_start_time'),pmt.to_pmt(float(self.rx_time[0]+self.rx_time[1])))
                          self.message_port_pub(pmt.intern('time_reference'), msg) #issue message
                          #print('key entry:', key)
                          #print('rx_time:', self.rx_time[0],self.rx_time[1], type(self.rx_time))
                          #print('')

              ################################################
              # Main Work Function
              ################################################

              else:

                  #determine what the sample number of the last sample in the input is
                  nitems = len(input_items[0]) + self.nitems_written(0)
                  #n_last_sample = (self.nitems_written(0) + len(input_items[0])) % self.calibrator_sample_interval

                  #while there are integration period boundaries present
                  while (nitems - self.offset) > self.calibrator_sample_interval:
                      
                      self.offset += self.calibrator_sample_interval

                      #writeindex = len(input_items[0]) - n_last_sample

                      #generate tags to be applied to data (pmt.cons does not work for metadata here, needs to be dict)
                      #we take in all the radio state from an external metadata constructor EXCEPT for cal state 
                      #since we really want that to line up with the transition.

                      current_rx_time = float(self.rx_time[0]+self.rx_time[1]) + self.offset/self.samp_rate

                      key = pmt.intern('metadata')
                      value = self.metadata_pmt
                      value = pmt.dict_add(value, pmt.to_pmt('cal_on'),pmt.to_pmt(int(self.last_cal_state)))

                      #apply tags

                      for i in range(self.num_channels):
                          self.add_item_tag(i, self.offset,key,value)
                          #self.add_item_tag(i, self.offset, pmt.intern("rx_time"), make_time_pair(time.time()))
                          self.add_item_tag(i, self.offset, pmt.intern("rx_time"), make_time_pair(current_rx_time)) #true to radio  timestamp
                          self.add_item_tag(i, self.offset, pmt.intern("rx_freq"), pmt.to_pmt(float(self.center_frequency)))

                      if self.next_cal_time:
                          if (current_rx_time >= self.next_cal_time): #put this after the metadata write becasue we want it to lag a cycle
                              self.last_cal_state = self.cal_state
                              self.next_cal_time = None


                      if self.last_cal_state != self.cal_state:

                          ########################################
                          #issue command to usrp for next state of calibrator, 
                          #needs to be a timed command so it ends up synced with the integration periods
                          #only do this if we are changing things
                          #######################################

                          #set command time for approx 1 cycle hence (winds up being less when recieved at SDR)
                          #I probably need to fix this to actually match the time as recorded by the SDR

                          rftime = time.time() - float(self.rx_time[0]+self.rx_time[1])  #get the actual exact time since the radio started sampling
                          current_num_integration_cycles = int((rftime)/self.integration_time) #number of cycles that have been completed before now
                          self.next_cal_time = float(self.rx_time[0]+self.rx_time[1]) + (current_num_integration_cycles +1)*self.integration_time

                          command_time = pmt.cons(pmt.from_uint64(int(self.next_cal_time)),pmt.from_double(self.next_cal_time-int(self.next_cal_time)))
                          #command_time = make_time_pair(self.next_cal_time)
                          msg = pmt.make_dict()
                          msg = pmt.dict_add(msg, pmt.to_pmt('time'), command_time)

                          self.message_port_pub(pmt.intern('command'), msg) #issue message

                          #issue command to toggle gpio

                          set_gpio = pmt.make_dict()
                          set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('bank'), pmt.to_pmt('FP0A'))
                          set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('attr'), pmt.to_pmt('OUT'))
                          set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('value'), pmt.from_double(self.cal_state))
                          set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('mask'), pmt.from_double(self.cal_mask))

                          msg = pmt.make_dict()
                          msg = pmt.dict_add(msg, pmt.to_pmt('gpio'), set_gpio)

                          self.message_port_pub(pmt.intern('command'), msg) #issue message


                          #clear command time 

                          msg = pmt.make_dict()
                          msg = pmt.dict_add(msg, pmt.to_pmt('time'), pmt.PMT_NIL)

                          self.message_port_pub(pmt.intern('command'), msg) #issue message

                          #self.message_port_pub(pmt.intern('command'), pmt.cons(pmt.to_pmt('time'), pmt.PMT_NIL))

                          #self.last_cal_state = self.cal_state

              for i in range(self.num_channels):
                  output_items[i][:] = input_items[i]
              return len(output_items[0])
    cal_mask: calibrator_mask
    cal_state: cal_on
    center_frequency: freq
    integration_time: tag_period/samp_rate
    metadata_pmt: metadata_dict
    num_channels: num_channels
    samp_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: num_bins
  id: parameter
  parameters:
    label: num_bins
    type: intx
    value: '256'
  states: {}
- name: num_integrations
  id: parameter
  parameters:
    label: num_integrations
    type: intx
    value: '100000'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      calibrator_control_mask = self.calibrator_mask
      self.usrp0.set_gpio_attr('FP0A', 'CTRL', 0x000, 0xFFF ^ calibrator_control_mask)  #set pins 2 and 3 manual
      self.usrp0.set_gpio_attr('FP0A', 'DDR', 0xFFF, calibrator_control_mask) #set pins 2 and 3 as output
      self.usrp0.set_gpio_attr('FP0A', 'OUT', 0x000 , calibrator_control_mask)
    section: main_after_init
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    alias: usrp0
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: rf_freq
    center_freq1: rf_freq
    dc_offs_enb0: auto
    dc_offs_enb1: auto
    dev_addr: '"addr=172.25.14.11"'
    gain0: rf_gain
    gain1: rf_gain
    iq_imbal_enb0: auto
    iq_imbal_enb1: auto
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: weighted_overlap_fft_0
  id: weighted_overlap_fft
  parameters:
    fft_window: fft_window
    num_bins: num_bins
    num_integrations: num_integrations
  states: {}
- name: weighted_overlap_fft_0_0
  id: weighted_overlap_fft
  parameters:
    fft_window: fft_window
    num_bins: num_bins
    num_integrations: num_integrations
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '5557'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5558
    pass_tags: 'True'
    timeout: '100'
    type: complex
    vlen: '2'
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5559
    timeout: '100'
    type: complex
    vlen: '2'
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5563
    timeout: '100'
    type: complex
    vlen: 4*num_bins
  states: {}
- name: zeromq_pub_sink_1_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5562
    pass_tags: 'True'
    timeout: '100'
    type: complex
    vlen: 4*num_bins
  states: {}
- name: zeromq_pub_sink_2
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5560
    pass_tags: 'True'
    timeout: '100'
    type: complex
    vlen: 4*num_bins
  states: {}
- name: zeromq_pub_sink_2_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5561
    timeout: '100'
    type: complex
    vlen: 4*num_bins
  states: {}

connections:
- [Covariance_Matrix_1, '0', blocks_streams_to_vector_1, '0']
- [Covariance_Matrix_1, '1', blocks_streams_to_vector_1, '1']
- [Covariance_Matrix_1, '2', blocks_streams_to_vector_1, '2']
- [Covariance_Matrix_1, '3', blocks_streams_to_vector_1, '3']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0_0_0_0, '0']
- [blocks_message_strobe_0, strobe, calibrator_control_strobe, strobe]
- [blocks_multiply_const_vxx_1, '0', blocks_streams_to_vector_0_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_streams_to_vector_0_0_0, '3']
- [blocks_multiply_const_vxx_1_0_0, '0', blocks_streams_to_vector_0_0_0, '1']
- [blocks_multiply_const_vxx_1_0_0_0, '0', blocks_streams_to_vector_0_0_0, '2']
- [blocks_multiply_const_xx_0_0_0_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_multiply_const_xx_0_0_0_0, '0', zeromq_pub_sink_2, '0']
- [blocks_multiply_const_xx_0_0_0_0, '0', zeromq_pub_sink_2_0, '0']
- [blocks_streams_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_streams_to_vector_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_streams_to_vector_0_0_0, '0', zeromq_pub_sink_1, '0']
- [blocks_streams_to_vector_0_0_0, '0', zeromq_pub_sink_1_0, '0']
- [blocks_streams_to_vector_1, '0', blocks_integrate_xx_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_vector_to_streams_0, '1', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_multiply_const_vxx_1_0_0_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_multiply_const_vxx_1_0, '0']
- [calibrator_control_strobe, command, uhd_usrp_source_1, command]
- [calibrator_control_strobe_0, '0', blocks_streams_to_vector_0, '0']
- [calibrator_control_strobe_0, '0', weighted_overlap_fft_0, '0']
- [calibrator_control_strobe_0, '1', blocks_streams_to_vector_0, '1']
- [calibrator_control_strobe_0, '1', weighted_overlap_fft_0_0, '0']
- [calibrator_control_strobe_0, command, uhd_usrp_source_1, command]
- [calibrator_control_strobe_0, time_reference, blocks_msgpair_to_var_0, inpair]
- [uhd_usrp_source_1, '0', add_clock_tags, '0']
- [uhd_usrp_source_1, '0', calibrator_control_strobe_0, '0']
- [uhd_usrp_source_1, '1', add_clock_tags_0, '0']
- [uhd_usrp_source_1, '1', calibrator_control_strobe_0, '1']
- [weighted_overlap_fft_0, '0', Covariance_Matrix_1, '0']
- [weighted_overlap_fft_0_0, '0', Covariance_Matrix_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
