options:
  parameters:
    generate_options: no_gui
    id: radio_process
    output_language: python
    run_options: run
    title: radio_process
  states: {}

blocks:
- name: beam_switch
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cal_on
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: cal_pwr
  id: variable
  parameters:
    value: np.array([1])
  states: {}
- name: cal_values
  id: variable
  parameters:
    value: np.repeat(np.nan, num_bins)
  states: {}
- name: calibrator_mask
  id: variable
  parameters:
    value: '0b000000000011'
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc_samples*np.hamming(4*num_bins)
  states: {}
- name: fft_window
  id: variable
  parameters:
    value: window.blackmanharris(num_bins)
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1420000000'
  states: {}
- name: glat
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: glon
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: is_running
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: motor_az
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: motor_el
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/num_bins)
  states: {}
- name: sinc_samples
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: soutrack
  id: variable
  parameters:
    value: '"at_stow"'
  states: {}
- name: tag_period
  id: variable
  parameters:
    value: num_bins*num_integrations
  states: {}
- name: tcal
  id: variable
  parameters:
    value: np.array([290])
  states: {}
- name: tsys
  id: variable
  parameters:
    value: np.array([171])
  states: {}
- name: vlsr
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: add_clock_tags
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt

      def make_time_pair(t):
          return pmt.make_tuple(pmt.to_pmt(int(np.trunc(t))), pmt.to_pmt(t - int(np.trunc(t))))

      class clk(gr.sync_block):
          def __init__(self, nsamps=8192):
              gr.sync_block.__init__(
                  self,
                  name='Add Clock Tags',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.pmt_key = pmt.intern("rx_time")
              self.offset = 0
              self.nsamps = nsamps
       
          def work(self, input_items, output_items):
              nitems = len(input_items[0]) + self.nitems_written(0)
              if self.nitems_written(0) == 0:
                  self.add_item_tag(0, 0, self.pmt_key, make_time_pair(time.time()))
              while ((nitems - self.offset) > self.nsamps):
                  self.offset += self.nsamps
                  self.add_item_tag(0, self.offset, self.pmt_key, make_time_pair(time.time()))
              output_items[0][:] = input_items[0] # copy input to output
              return len(output_items[0])
    nsamps: tag_period
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_bins
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: num_bins*3
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: num_bins*2
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: num_bins
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: num_integrations
    type: float
    vlen: num_bins
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.to_pmt(is_running)
    period: '100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-num_bins:]
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*num_bins:3*num_bins]
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[num_bins:2*num_bins]
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:num_bins]
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[(tsys[0] + tcal[0])/(value * cal_pwr[0]) for value in cal_values]'
    type: float
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0/float(num_integrations)
    type: float
    vlen: num_bins
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: num_bins*num_integrations
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_bins
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_bins
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: num_bins
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: num_bins
    type: complex
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("rx_freq")
    nsamps: tag_period
    type: complex
    value: pmt.to_pmt(float(freq))
  states: {}
- name: blocks_tags_strobe_0_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("metadata")
    nsamps: tag_period
    type: complex
    value: 'pmt.to_pmt({"num_bins": num_bins, "samp_rate": samp_rate, "num_integrations": num_integrations, "motor_az": motor_az, "motor_el": motor_el, "freq": freq, "tsys": [float(n) for n in tsys], "tcal": [float(n) for n in tcal], "cal_pwr": [float(n) for n in cal_pwr], "vlsr": vlsr, "glat": glat, "glon": glon, "soutrack": soutrack, "bsw": beam_switch, "cal_on":cal_on})'
  states: {}
- name: calibrator_control_strobe
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nblock to generate calibrator control commands for the X300 radio. \nnote that this block assumes a latency lower than the calibrator cycle time\nand will break if that condition is not met\n\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport numpy as np\nfrom gnuradio import gr \nimport pmt\nimport time\nimport uhd\n\nclass msg_blk(gr.sync_block):\n    def __init__(self, calibrator_mask=0xFFF,cal_state=False):\n        gr.sync_block.__init__(\n            self,\n            name=\"calibrator_msg_block\",\n            in_sig=None,\n           out_sig=None\n        )\n\n        #input parameters\n        self.calibrator_mask = calibrator_mask\n        self.cal_state = cal_state\n\n        #derived variables\n\n        self.last_cal_state = False\n    \n        self.message_port_register_in(pmt.intern('strobe'))\n        self.message_port_register_out(pmt.intern('command'))\n        \n        self.set_msg_handler(pmt.intern('strobe'), self.handle_msg)\n\n    def handle_msg(self, msg):\n\n        #send message to define next calibrator state change\n\n        if self.last_cal_state != self.cal_state:\n            if self.cal_state:\n                new_cal_value = 0xFFF\n            else:\n                new_cal_value = 0x000\n\n        #issue command to set toggle gpio\n\n        set_gpio = pmt.make_dict()\n        set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('bank'), pmt.to_pmt('FP0A'))\n        set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('attr'), pmt.to_pmt('OUT'))\n        set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('value'), pmt.from_double(new_cal_value))\n        set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('mask'), pmt.from_double(self.calibrator_mask))\n\n        msg = pmt.make_dict()\n        msg = pmt.dict_add(msg, pmt.to_pmt('gpio'), set_gpio)\n\n        self.message_port_pub(pmt.intern('command'), msg) #issue message\n\n        self.last_cal_state = self.cal_state\n\n        "
    cal_state: cal_on
    calibrator_mask: calibrator_mask
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: num_bins*num_integrations
    long_form: 'False'
    type: cc
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_bins
    forward: 'True'
    nthreads: '3'
    shift: 'True'
    type: complex
    window: fft_window
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: num_bins
  id: parameter
  parameters:
    label: num_bins
    type: intx
    value: '256'
  states: {}
- name: num_integrations
  id: parameter
  parameters:
    label: num_integrations
    type: intx
    value: '100000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"soapy=0"'
    bb_gain0: '0'
    freq0: freq
    gain0: '49'
    gain_mode0: 'False'
    if_gain0: '0'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      calibrator_control_mask = self.calibrator_mask
      self.usrp0.set_gpio_attr('FP0A', 'CTRL', 0x000, 0xFFF ^ calibrator_control_mask)  #set pins 2 and 3 manual
      self.usrp0.set_gpio_attr('FP0A', 'DDR', 0xFFF, calibrator_control_mask) #set pins 2 and 3 as output
      self.usrp0.set_gpio_attr('FP0A', 'OUT', 0x000 , calibrator_control_mask)
    section: main_after_init
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    alias: usrp0
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: rf_freq
    dc_offs_enb0: auto
    dev_addr: '"addr=172.25.14.11"'
    gain0: rf_gain
    iq_imbal_enb0: auto
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '5557'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5558
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5559
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5563
    timeout: '100'
    type: float
    vlen: num_bins
  states: {}
- name: zeromq_pub_sink_1_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5562
    pass_tags: 'True'
    timeout: '100'
    type: float
    vlen: num_bins
  states: {}
- name: zeromq_pub_sink_2
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5560
    pass_tags: 'True'
    timeout: '100'
    type: float
    vlen: num_bins
  states: {}
- name: zeromq_pub_sink_2_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5561
    timeout: '100'
    type: float
    vlen: num_bins
  states: {}

connections:
- [add_clock_tags, '0', blocks_add_xx_0_0, '1']
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_add_xx_0_0, '0', blocks_selector_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_message_strobe_0, strobe, calibrator_control_strobe, strobe]
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_1, '0', zeromq_pub_sink_1, '0']
- [blocks_multiply_const_vxx_1, '0', zeromq_pub_sink_1_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_xx_0, '0', zeromq_pub_sink_2, '0']
- [blocks_multiply_const_xx_0, '0', zeromq_pub_sink_2_0, '0']
- [blocks_selector_0, '0', dc_blocker_xx_0, '0']
- [blocks_selector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_selector_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_1, '0']
- [blocks_skiphead_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_tags_strobe_0, '0', blocks_add_xx_0_0, '0']
- [blocks_tags_strobe_0_0, '0', blocks_add_xx_0_0, '2']
- [calibrator_control_strobe, command, uhd_usrp_source_1, command]
- [dc_blocker_xx_0, '0', blocks_skiphead_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', add_clock_tags, '0']
- [uhd_usrp_source_1, '0', add_clock_tags, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
