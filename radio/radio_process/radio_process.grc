options:
  parameters:
    generate_options: no_gui
    id: radio_process
    output_language: python
    run_options: run
    title: radio_process
  states: {}

blocks:
- name: beam_switch
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cal_on
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cal_pwr
  id: variable
  parameters:
    value: np.array([1]*num_channels**2)
  states: {}
- name: cal_values
  id: variable
  parameters:
    value: cal_values_real+1j*cal_values_imag
  states: {}
- name: cal_values_imag
  id: variable
  parameters:
    value: np.zeros((num_channels**2,num_bins))
  states: {}
- name: cal_values_real
  id: variable
  parameters:
    value: np.ones((num_channels**2,num_bins))
  states: {}
- name: calibrator_mask
  id: variable
  parameters:
    value: '0b000000000011'
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc_samples*np.hamming(4*num_bins)
  states: {}
- name: fft_window
  id: variable
  parameters:
    value: window.blackmanharris(num_bins)
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1420000000'
  states: {}
- name: glat
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: glon
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: is_running
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: metadata_dict
  id: variable
  parameters:
    value: 'pmt.to_pmt({"num_bins": num_bins, "samp_rate": samp_rate, "num_integrations": num_integrations, "motor_az": motor_az, "motor_el": motor_el, "freq": freq, "tsys": [float(n) for n in tsys], "tcal": [float(n) for n in tcal], "cal_pwr": [float(n) for n in cal_pwr], "vlsr": vlsr, "glat": glat, "glon": glon, "soutrack": soutrack, "bsw": beam_switch})'
  states: {}
- name: motor_az
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: motor_el
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/num_bins)
  states: {}
- name: sinc_samples
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: soutrack
  id: variable
  parameters:
    value: '"at_stow"'
  states: {}
- name: tag_period
  id: variable
  parameters:
    value: num_bins*num_integrations
  states: {}
- name: tcal
  id: variable
  parameters:
    value: np.array([290]*num_channels)
  states: {}
- name: tsys
  id: variable
  parameters:
    value: np.array([171]*num_channels)
  states: {}
- name: vlsr
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: add_clock_tags
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt

      def make_time_pair(t):
          return pmt.make_tuple(pmt.to_pmt(int(np.trunc(t))), pmt.to_pmt(t - int(np.trunc(t))))

      class clk(gr.sync_block):
          def __init__(self, nsamps=8192):
              gr.sync_block.__init__(
                  self,
                  name='Add Clock Tags',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.pmt_key = pmt.intern("rx_time")
              self.offset = 0
              self.nsamps = nsamps
       
          def work(self, input_items, output_items):
              nitems = len(input_items[0]) + self.nitems_written(0)
              if self.nitems_written(0) == 0:
                  self.add_item_tag(0, 0, self.pmt_key, make_time_pair(time.time()))
              while ((nitems - self.offset) > self.nsamps):
                  self.offset += self.nsamps
                  self.add_item_tag(0, self.offset, self.pmt_key, make_time_pair(time.time()))
              output_items[0][:] = input_items[0] # copy input to output
              return len(output_items[0])
    nsamps: tag_period
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: num_integrations
    type: complex
    vlen: num_bins*(num_channels**2)
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.to_pmt(is_running)
    period: '100'
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: cal_values[0]
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_xx_0_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0/float(num_integrations)
    type: complex
    vlen: num_bins*(num_channels**2)
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("rx_freq")
    nsamps: tag_period
    type: complex
    value: pmt.to_pmt(float(freq))
  states: {state: disabled}
- name: blocks_tags_strobe_0_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("metadata")
    nsamps: tag_period
    type: complex
    value: 'pmt.to_pmt({"num_bins": num_bins, "samp_rate": samp_rate, "num_integrations": num_integrations, "motor_az": motor_az, "motor_el": motor_el, "freq": freq, "tsys": [float(n) for n in tsys], "tcal": [float(n) for n in tcal], "cal_pwr": [float(n) for n in cal_pwr], "vlsr": vlsr, "glat": glat, "glon": glon, "soutrack": soutrack, "bsw": beam_switch, "cal_on":cal_on})'
  states: {state: disabled}
- name: calibrator_control_strobe
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nblock to generate calibrator control commands for the X300 radio. \nnote that this block assumes a latency lower than the calibrator cycle time\nand will break if that condition is not met\n\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport numpy as np\nfrom gnuradio import gr \nimport pmt\nimport time\nimport uhd\n\nclass msg_blk(gr.sync_block):\n    def __init__(self, calibrator_mask=0xFFF,cal_state=False):\n        gr.sync_block.__init__(\n            self,\n            name=\"calibrator_msg_block\",\n            in_sig=None,\n           out_sig=None\n        )\n\n        #input parameters\n        self.calibrator_mask = calibrator_mask\n        self.cal_state = cal_state\n\n        #derived variables\n\n        self.last_cal_state = False\n    \n        self.message_port_register_in(pmt.intern('strobe'))\n        self.message_port_register_out(pmt.intern('command'))\n        \n        self.set_msg_handler(pmt.intern('strobe'), self.handle_msg)\n\n    def handle_msg(self, msg):\n\n        #send message to define next calibrator state change\n\n        if self.last_cal_state != self.cal_state:\n            if self.cal_state:\n                new_cal_value = 0xFFF\n            else:\n                new_cal_value = 0x000\n\n        #issue command to set toggle gpio\n\n        set_gpio = pmt.make_dict()\n        set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('bank'), pmt.to_pmt('FP0A'))\n        set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('attr'), pmt.to_pmt('OUT'))\n        set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('value'), pmt.from_double(new_cal_value))\n        set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('mask'), pmt.from_double(self.calibrator_mask))\n\n        msg = pmt.make_dict()\n        msg = pmt.dict_add(msg, pmt.to_pmt('gpio'), set_gpio)\n\n        self.message_port_pub(pmt.intern('command'), msg) #issue message\n\n        self.last_cal_state = self.cal_state\n\n        "
    cal_state: cal_on
    calibrator_mask: calibrator_mask
  states: {state: disabled}
- name: calibrator_control_strobe_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nblock to generate calibrator control commands for the X300 radio. \nnote that this block assumes a latency lower than the calibrator cycle time\nand will break if that condition is not met. modified to add timestamps on 2024/12/23\n\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport numpy as np\nfrom gnuradio import gr \nimport pmt\nimport time\nimport uhd\n\ndef make_time_pair(t):\n    return pmt.make_tuple(\n        pmt.to_pmt(int(np.trunc(t))), pmt.to_pmt(t - int(np.trunc(t)))\n    )\n\nclass tagging_and_ctl(gr.sync_block):\n    def __init__(self, num_channels=1, cal_mask=0xFFF, cal_state=0, cal_interval=1.0, samp_rate=32e3, center_frequency=1.42e9, metadata_pmt=pmt.to_pmt({\"num_bins\":512})):\n        gr.sync_block.__init__(\n            self,\n            name=\"metadata_tagging_and_control\",\n            in_sig=[np.complex64]*num_channels,\n            out_sig=[np.complex64]*num_channels\n        )\n\n        #input parameters\n        self.cal_mask = cal_mask\n        self.cal_interval = cal_interval\n        self.cal_state = cal_state\n        self.samp_rate = samp_rate\n        self.num_channels = num_channels\n        self.metadata_pmt = metadata_pmt\n        self.center_frequency=center_frequency\n\n        #fixed derived variables\n\n        self.calibrator_sample_interval = int(self.samp_rate * self.cal_interval)\n\n        self.last_cal_state = False\n        self.rx_time = pmt.to_python(pmt.cons(pmt.from_uint64(int(0)),pmt.from_double(0)))\n\n        #self.message_port_register_in(pmt.intern('get_gpio'))\n        self.message_port_register_out(pmt.intern('command'))\n        #self.set_msg_handler(pmt.intern('gpio_command'), self.handle_msg)\n\n    def work(self, input_items, output_items):\n\n\n        #when SDR first starts capture its timestamp off the first sample. use to time all subsequent events\n\n        tags = self.get_tags_in_window(0, 0, len(input_items[0]))\n\n        for tag in tags:\n            key = pmt.to_python(tag.key) # convert from PMT to python string\n            if key == \"rx_time\":\n                self.rx_time = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was\n                #print('key entry:', key)\n                #print('value:', self.rx_time[0],self.rx_time[1], type(self.rx_time))\n                #print('')\n\n        #determine what the sample number of the last sample in the input is\n\n        n_last_sample = (self.nitems_written(0) + len(input_items[0])) % self.calibrator_sample_interval\n\n        #determine calibrator state at samples being recieved\n\n        #check if we are seeing a sample we are interested in adding a tag to\n        if (n_last_sample-len(input_items[0])) <= 0:\n\n            writeindex = len(input_items[0]) - n_last_sample\n\n            #generate tags to be applied to data (pmt.cons does not work for metadata here, needs to be dict)\n            #we take in all the radio state from an external metadata constructor EXCEPT for cal state \n            #since we really want that to line up with the transition.\n\n            key = pmt.intern('metadata')\n            value = self.metadata_pmt\n            value = pmt.dict_add(value, pmt.to_pmt('cal_on'),pmt.to_pmt(int(self.last_cal_state)))\n            #value = pmt.cons(pmt.to_pmt('cal_on'), pmt.from_bool(self.last_cal_state))\n\n            #apply tags\n\n            for i in range(self.num_channels):\n                self.add_item_tag(i, self.nitems_written(0) + writeindex,key,value)\n                self.add_item_tag(i, self.nitems_written(0) + writeindex, pmt.intern(\"rx_time\"), make_time_pair(time.time()))\n                self.add_item_tag(i, self.nitems_written(0) + writeindex, pmt.intern(\"rx_freq\"), pmt.to_pmt(float(self.center_frequency)))\n\n\n            if self.last_cal_state != self.cal_state:\n\n                ########################################\n                #issue command to usrp for next state of calibrator, \n                #needs to be a timed command so it ends up synced with the integration periods\n                #only do this if we are changing things\n                #######################################\n\n                #set command time for approx 1 cycle hence (winds up being less when recieved at SDR)\n                #I probably need to fix this to actually match the time as recorded by the SDR\n\n                command_time = pmt.cons(pmt.from_uint64(int((self.nitems_written(0)+len(input_items[0]))/self.calibrator_sample_interval+self.cal_interval+self.rx_time[0])),pmt.from_double(self.rx_time[1]))\n                msg = pmt.make_dict()\n                msg = pmt.dict_add(msg, pmt.to_pmt('time'), command_time)\n\n                self.message_port_pub(pmt.intern('command'), msg) #issue message\n\n                #issue command to toggle gpio\n\n                set_gpio = pmt.make_dict()\n                set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('bank'), pmt.to_pmt('FP0A'))\n                set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('attr'), pmt.to_pmt('OUT'))\n                set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('value'), pmt.from_double(self.cal_state))\n                set_gpio = pmt.dict_add(set_gpio, pmt.to_pmt('mask'), pmt.from_double(self.cal_mask))\n\n                msg = pmt.make_dict()\n                msg = pmt.dict_add(msg, pmt.to_pmt('gpio'), set_gpio)\n\n                self.message_port_pub(pmt.intern('command'), msg) #issue message\n\n\n                #clear command time \n\n                msg = pmt.make_dict()\n                msg = pmt.dict_add(msg, pmt.to_pmt('time'), pmt.PMT_NIL)\n\n                self.message_port_pub(pmt.intern('command'), msg) #issue message\n\n                #self.message_port_pub(pmt.intern('command'), pmt.cons(pmt.to_pmt('time'), pmt.PMT_NIL))\n\n                self.last_cal_state = self.cal_state\n\n        for i in range(self.num_channels):\n            output_items[i][:] = input_items[i]\n        return len(output_items[0])\n        "
    cal_interval: tag_period/samp_rate
    cal_mask: calibrator_mask
    cal_state: cal_on
    center_frequency: freq
    metadata_pmt: metadata_dict
    num_channels: num_channels
    samp_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: num_bins
  id: parameter
  parameters:
    label: num_bins
    type: intx
    value: '256'
  states: {}
- name: num_channels
  id: parameter
  parameters:
    label: num_channels
    type: intx
    value: '1'
  states: {}
- name: num_integrations
  id: parameter
  parameters:
    label: num_integrations
    type: intx
    value: '100000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"soapy=0"'
    bb_gain0: '0'
    freq0: freq
    gain0: '49'
    gain_mode0: 'False'
    if_gain0: '0'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      calibrator_control_mask = self.calibrator_mask
      self.usrp0.set_gpio_attr('FP0A', 'CTRL', 0x000, 0xFFF ^ calibrator_control_mask)  #set pins 2 and 3 manual
      self.usrp0.set_gpio_attr('FP0A', 'DDR', 0xFFF, calibrator_control_mask) #set pins 2 and 3 as output
      self.usrp0.set_gpio_attr('FP0A', 'OUT', 0x000 , calibrator_control_mask)
    section: main_after_init
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    alias: usrp0
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: rf_freq
    dc_offs_enb0: auto
    dev_addr: '"addr=172.25.14.11"'
    gain0: rf_gain
    iq_imbal_enb0: auto
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: weighted_overlap_fft_0
  id: weighted_overlap_fft
  parameters:
    fft_window: fft_window
    num_bins: num_bins
    num_integrations: num_integrations
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '5557'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5558
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5559
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5563
    timeout: '100'
    type: complex
    vlen: num_bins
  states: {}
- name: zeromq_pub_sink_1_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5562
    pass_tags: 'True'
    timeout: '100'
    type: complex
    vlen: num_bins
  states: {}
- name: zeromq_pub_sink_2
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5560
    pass_tags: 'True'
    timeout: '100'
    type: complex
    vlen: num_bins
  states: {}
- name: zeromq_pub_sink_2_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5561
    timeout: '100'
    type: complex
    vlen: num_bins
  states: {}

connections:
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0_0_0_0, '0']
- [blocks_message_strobe_0, strobe, calibrator_control_strobe, strobe]
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', zeromq_pub_sink_1, '0']
- [blocks_multiply_const_vxx_1, '0', zeromq_pub_sink_1_0, '0']
- [blocks_multiply_const_xx_0_0_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_xx_0_0_0_0, '0', zeromq_pub_sink_2, '0']
- [blocks_multiply_const_xx_0_0_0_0, '0', zeromq_pub_sink_2_0, '0']
- [calibrator_control_strobe, command, uhd_usrp_source_1, command]
- [calibrator_control_strobe_0, '0', weighted_overlap_fft_0, '0']
- [calibrator_control_strobe_0, '0', zeromq_pub_sink_0, '0']
- [calibrator_control_strobe_0, '0', zeromq_pub_sink_0_0, '0']
- [calibrator_control_strobe_0, command, uhd_usrp_source_1, command]
- [osmosdr_source_0, '0', add_clock_tags, '0']
- [uhd_usrp_source_1, '0', add_clock_tags, '0']
- [uhd_usrp_source_1, '0', calibrator_control_strobe_0, '0']
- [weighted_overlap_fft_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [weighted_overlap_fft_0, '0', blocks_multiply_conjugate_cc_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
