options:
  parameters:
    generate_options: no_gui
    id: radio_save_raw_dual_channel
    output_language: python
    run_options: run
    title: radio_save_raw_dual_channel
  states: {}

blocks:
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: directory_name
  id: parameter
  parameters:
    label: directory_name
    type: str
    value: '"./rf_data"'
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    channel1: ch1
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '2'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: '''now'''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: directory_name
    uuid: ''
    vlen: '1'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '2400000'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5558
    pass_tags: 'True'
    timeout: '100'
    type: complex
    vlen: '2'
  states: {}

connections:
- [blocks_vector_to_streams_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [blocks_vector_to_streams_0, '1', gr_digital_rf_digital_rf_sink_0, '1']
- [zeromq_sub_source_0, '0', blocks_vector_to_streams_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
